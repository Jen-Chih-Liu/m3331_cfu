# Keil uVision project HSUSBD_HID_CFU.uvprojx, settings and files
target HSUSBD_HID_CFU_AP0 (6220000::V6.22::ARMCLANG)
  device: M3334KIGAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.2
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M33") FPU2
  output: HSUSBD_HID_CFU_AP0
  AfterMake: fromelf --bincombined ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: post_build.bat @L
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: ACTIVE_BANK=0, CFU_DBG=1,
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\;..\Module;..\..\..\..\Library\Device\Nuvoton\m3331\Config;..\..\..\..\Library\Device\Nuvoton\m3331\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\AP0_OFFSET.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m3331/Source/: system_m3331.c startup_m3331.c
  group User
    ../: main.c descriptors.c hid_transfer.c
  group Cfu
    ../Module/: ComponentFwUpdate.c ICompFwUpdateBsp.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c hsusbd.c fmc.c timer.c
target HSUSBD_HID_CFU_AP1 (6220000::V6.22::ARMCLANG)
  device: M3334KIGAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.2
  cpu: as above
  output: HSUSBD_HID_CFU_AP1
  AfterMake: fromelf --bincombined ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: post_build.bat @L
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: ACTIVE_BANK=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\AP1_OFFSET.sct
  link misc: as above
